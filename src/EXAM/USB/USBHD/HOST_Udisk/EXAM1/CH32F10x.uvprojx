# Keil uVision project CH32F10x.uvprojx, settings and files
target CH32F10x (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: CH32F103R8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F10x +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\SRC\CMSIS;..\..\..\..\SRC\Debug;..\..\..\..\SRC\StdPeriphDriver\inc;..\..\Udisk_Lib;..\EXAM1;..\..\Udisk_Lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: Main.c ch32f10x_it.c system_ch32f10x.c
  group startup
    ../../../../SRC/Startup/: startup_ch32f10x.s
  group core
    ../../../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../../../SRC/Debug/: debug.c
  group peripheral
    ../../../../SRC/StdPeriphDriver/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_usb.c ch32f10x_usb_host.c ch32f10x_wwdg.c
  group Udisk
    ../../Udisk_Lib/: CH32F103UFI.C CH32F103UFI.lib
